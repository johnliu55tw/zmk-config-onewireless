## boards/shields/onewireless/Kconfig.defconfig
```kconfig
if SHIELD_ONEWIRELESS

config ZMK_KEYBOARD_NAME
    default "One Wireless"

endif
```
